# Keil uVision project Car2.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MSP432P4111 Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x01000000,0x00040000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Car2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P4111__
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x1000000 size 0x40000
  group Source Group 1
    ./: Car.c ADC14.c ADC14.h Common.h ControlPins.c ControlPins.h CortexM.c CortexM.h leds.c leds.h switches.c switches.h SysTickTimer.c SysTickTimer.h Timer32.c Timer32.h TimerA.c TimerA.h uart.c uart.h Init.c Init.h
software components: CMSIS:CORE 5.0.1, Device:Startup 3.2.2
